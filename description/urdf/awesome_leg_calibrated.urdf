Commit message: fixed missing tip offset

File: description/urdf/awesome_leg_calibrated.urdf (robot description, URDF)
Before this commit: robot awesome_leg, 4 links, 3 joints
Joints:
- joint tip_joint: origin (none) -> xyz=0.45 0.0 -0.02
